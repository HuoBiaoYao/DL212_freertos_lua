# Keil uVision project DL212_freertos_lua.uvprojx, settings and files
target DL212_freertos_lua (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L151RD STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x60000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DL212_freertos_lua
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32L1XX_HD
  c include: .\Libraries\CMSIS\Include;.\Libraries\STM32L1xx_StdPeriph_Driver\inc;.\SRC&INH;.\SRC&INH\FreeRTOS\include;.\SRC&INH\FreeRTOS\portable\RVDS\ARM_CM3;.\SRC&INH\FreeRTOS\portable\MemMang;.\SRC&INH\SYSTEM;.\SRC&INH\hal;.\SRC&INH\hw;.\Libraries\STM32_USB-FS-Device_Driver\inc;.\SRC&INH\USB;.\SRC&INH\Abstract Data Type;.\SRC&INH\Modbus\include;.\SRC&INH\Modbus\port;.\SRC&INH\FreeRTOS-Plus-CLI;.\SRC&INH\lua-5.3.4\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ./SRC&INH/: main.c my_usb.c DL212_easy_mode.c stm32l1xx_it.c DL212.c Datalogger_Protocols.c qksort.c issort.c usart_idle_dma_modbus.c lua_task.c malloc.c
  group lua-5.3.4
    ./SRC&INH/lua-5.3.4/src/: lapi.c lauxlib.c lbaselib.c lbitlib.c lcode.c lcorolib.c lctype.c ldblib.c ldebug.c ldo.c ldump.c lfunc.c lgc.c linit.c liolib.c llex.c lmathlib.c lmem.c loadlib.c lobject.c lopcodes.c loslib.c lparser.c lstate.c lstring.c lstrlib.c ltable.c ltablib.c ltm.c lua.c luac.c lundump.c lutf8lib.c lvm.c lzio.c
  group freertos_core
    ./SRC&INH/freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group freertos_portable
    ./SRC&INH/freertos/portable/MemMang/: heap_4.c
    ./SRC&INH/freertos/portable/RVDS/ARM_CM3/: port.c
  group freemodbus
    ./SRC&INH/Modbus/source/: mb.c mbascii.c mbcrc.c mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbrtu.c mbtcp.c mbutils.c
  group freemodbus_port
    ./SRC&INH/Modbus/port/: portevent.c portfunction.c portserial.c porttimer.c
  group adt
    ./SRC&INH/Abstract Data Type/: arithmetic_expression.c bitree.c stack.c traverse.c mylist.c
  group system
    ./SRC&INH/SYSTEM/: delay.c sys.c
  group hal
    ./SRC&INH/hal/: hal_c_port.c hal_c_rs232.c hal_flash.c hal_fram.c hal_pwr.c hal_sdi12.c hal_se_port.c hal_sw12.c
  group hw
    ./SRC&INH/hw/: hw_sw12.c hw_flash.c hw_flash_at45db.c hw_fram_fm25cl64.c hw_pwr.c hw_rtc_m41t81.c hw_se_port.c hw_serial.c hw_spi.c hw_stm32_rtc.c hw_tim.c hw_usb.c
  group usb
    ./SRC&INH/USB/: usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group STM32L1xx_StdPeriph_Driver
    ./Libraries/STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_adc.c stm32l1xx_crc.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c misc.c
  group STM32_USB-FS-Device_Driver
    ./Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.0
